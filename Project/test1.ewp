# IAR project test1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..; ..\UserApp; ..\Library\inc; ..\HardWare; ..\Bsp
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group HardWare
    $EW_DIR$/Test1/HardWare/: adc.c exti.c pid.c pwm.c qi.c tim2.c
    $EW_DIR$/Test1/Library/src/: stm8s_clk.c
  group UserApp
    ./: main.c
